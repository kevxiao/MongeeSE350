# Keil uVision project p2.uvproj, settings and files
target P2 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: context_switching
  c flags: Optim=1
  c define: DEBUG_0 _DEBUG_HOTKEYS K_MSG_ENV
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: system_LPC17xx.c uart_polling.c printf.c main_svc.c uart_irq.c str_util.c
  group RTX Kernel Code
    ./src/: timer.c HAL.c k_rtx_init.c k_memory.c k_process.c sys_proc.c
  group User Code
    ./src/: user_proc.c test_proc.c
  group Documentation
    ./: README.txt
